# IAR project CAN_Tx_Rx.ewp, settings and files
configuration N32A455 (ARM, debug)
  General.OGChipSelectEditMenu: N32A455VE Nations N32A455VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32A455; USE_STDPERIPH_DRIVER; SYSCLK_FREQ=144000000
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32a455_std_periph_driver\inc; ..\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CAN_Tx_Rx.bin
  ILINK.IlinkOutputFile: CAN_Tx_Rx.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32a455.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32a455_std_periph_driver/src/: misc.c n32a455_bkp.c n32a455_can.c n32a455_dbg.c n32a455_flash.c n32a455_gpio.c n32a455_pwr.c n32a455_rcc.c n32a455_rtc.c n32a455_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32a455_EWARM.s
  group USER
    ../src/: main.c n32a455_it.c User_Can_Config.c User_LED_Config.c User_Systick_Config.c User_Usart_Config.c
