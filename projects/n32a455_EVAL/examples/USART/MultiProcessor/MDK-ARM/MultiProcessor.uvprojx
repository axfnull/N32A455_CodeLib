# Keil uVision project MultiProcessor.uvprojx, settings and files
target N32A455 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32A455VEL7 Nationstech
  pack: Nationstech.N32A455_DFP.1.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MultiProcessor +hex
  AfterMake: fromelf --bin --output=.\bin\MultiProcessor.bin .\Objects\MultiProcessor.axf
  AfterMake: fromelf --vhx -d --32x1 .\Objects\MultiProcessor.axf --output=.\bin\MultiProcessor.dua
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32A455, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32a455_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32a455.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32a455.c
  group FWLB
    ../../../../../../firmware/n32a455_std_periph_driver/src/: misc.c n32a455_exti.c n32a455_gpio.c n32a455_rcc.c n32a455_tim.c n32a455_usart.c
  group USER
    ../src/: main.c n32a455_it.c bsp_key.c bsp_led.c
  group DOC
    ../: readme.txt
