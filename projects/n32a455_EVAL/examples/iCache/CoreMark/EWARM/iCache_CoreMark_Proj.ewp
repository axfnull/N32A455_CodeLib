# IAR project iCache_CoreMark_Proj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32A455VE Nations N32A455VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32A455; USE_STDPERIPH_DRIVER; SYSCLK_FREQ=144000000
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32a455_std_periph_driver\inc; ..\..\..\..\bsp\inc; ..\inc; ..\coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iCache_CoreMark_Proj.bin
  ILINK.IlinkOutputFile: iCache_CoreMark_Proj.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32a455.c
  group COREMARK
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group DOC
    ../src/: readme.txt
  group FWLB
    ../../../../../../firmware/n32a455_std_periph_driver/src/: misc.c n32a455_adc.c n32a455_bkp.c n32a455_can.c n32a455_comp.c n32a455_crc.c n32a455_dac.c n32a455_dbg.c n32a455_dma.c n32a455_exti.c n32a455_flash.c n32a455_gpio.c n32a455_i2c.c n32a455_iwdg.c n32a455_opamp.c n32a455_pwr.c n32a455_qspi.c n32a455_rcc.c n32a455_rtc.c n32a455_sdio.c n32a455_spi.c n32a455_tim.c n32a455_usart.c n32a455_wwdg.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32a455_EWARM.s
  group USER
    ../src/: main.c n32a455_it.c
