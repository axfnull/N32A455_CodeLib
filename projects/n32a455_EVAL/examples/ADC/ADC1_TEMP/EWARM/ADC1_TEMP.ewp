# IAR project ADC1_TEMP.ewp, settings and files
configuration N32A455 (ARM, debug)
  General.OGChipSelectEditMenu: N32A455VE Nations N32A455VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32A455; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER; __TARGET_FPU_VFP; __FPU_PRESENT; DEFINEFLOAT
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32a455_std_periph_driver/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC1_TEMP.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32A455\N32A455xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32a455.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32a455_std_periph_driver/src/: misc.c n32a455_adc.c n32a455_dac.c n32a455_dma.c n32a455_exti.c n32a455_flash.c n32a455_gpio.c n32a455_rcc.c n32a455_tim.c n32a455_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32a455_EWARM.s
  group USER
    ../src/: main.c n32a455_it.c
