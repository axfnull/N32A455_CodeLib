# IAR project ALGO_Demo.ewp, settings and files
configuration N32A455 (ARM, debug)
  General.OGChipSelectEditMenu: N32A455VE Nations N32A455VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32A455; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR; __IAR_ARM
  ICCARM.CCDiagSuppress: Pe301
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32a455_std_periph_driver/inc; ../../../../bsp/inc; ../../../../../../firmware/n32a455_algo_lib/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ALGO_Demo.srec
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\firmware\n32a455_algo_lib\lib\n32a455_aes.lib; ..\..\..\..\..\..\firmware\n32a455_algo_lib\lib\n32a455_algo_common.lib; ..\..\..\..\..\..\firmware\n32a455_algo_lib\lib\n32a455_des.lib; ..\..\..\..\..\..\firmware\n32a455_algo_lib\lib\n32a455_hash.lib; ..\..\..\..\..\..\firmware\n32a455_algo_lib\lib\n32a455_rng.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ALGO
    ../../../../../../firmware/n32a455_algo_lib/lib/: n32a455_aes.lib n32a455_algo_common.lib n32a455_des.lib n32a455_hash.lib n32a455_rng.lib
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32a455.c
  group FWLB
    ../../../../../../firmware/n32a455_std_periph_driver/src/: misc.c n32a455_flash.c n32a455_gpio.c n32a455_rcc.c n32a455_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32a455_EWARM.s
  group USER
    ../src/: main.c n32a455_it.c
