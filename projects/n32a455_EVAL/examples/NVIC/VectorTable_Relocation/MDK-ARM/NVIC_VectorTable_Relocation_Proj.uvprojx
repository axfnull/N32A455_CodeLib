# Keil uVision project NVIC_VectorTable_Relocation_Proj.uvprojx, settings and files
target N32A455 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32A455VEL7 Nationstech
  pack: Nationstech.N32A455_DFP.1.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NVIC_VectorTable_Relocation_Proj +hex
  AfterMake: fromelf --bin --output=.\bin\NVIC_VectorTable_Relocation_Proj.bin .\Objects\NVIC_VectorTable_Relocation_Proj.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32A455, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32a455_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32a455.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32a455.c
  group FWLB
    ../../../../../../firmware/n32a455_std_periph_driver/src/: misc.c n32a455_adc.c n32a455_bkp.c n32a455_can.c n32a455_crc.c n32a455_dac.c n32a455_dbg.c n32a455_dma.c n32a455_exti.c n32a455_flash.c n32a455_gpio.c n32a455_i2c.c n32a455_iwdg.c n32a455_pwr.c n32a455_qspi.c n32a455_rcc.c n32a455_rtc.c n32a455_sdio.c n32a455_spi.c n32a455_tim.c n32a455_usart.c n32a455_wwdg.c
  group BSP
    ../../../../bsp/src/: log.c
  group USER
    ../src/: main.c n32a455_it.c
  group DOC
    ../: readme.txt
target N32A455_SRAM (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: N32A455VEL7 Nationstech
  pack: Nationstech.N32A455_DFP.1.0.5
  cpu: as above
  output: NVIC_VectorTable_Relocation_Proj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32A455, USE_STDPERIPH_DRIVER, VECT_TAB_SRAM
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20010000 size 0x8000
  memory RVCT9: RAM 0x20018000 size 0xc000
